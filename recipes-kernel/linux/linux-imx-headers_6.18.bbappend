require recipes-kernel/linux/linux-imx-somlabs-src.inc
