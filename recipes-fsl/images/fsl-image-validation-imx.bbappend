PACKAGE_INSTALL += " \
    somlabs-demo \
    "

IMAGE_FEATURES_remove = "splash"
