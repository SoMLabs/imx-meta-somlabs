FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PACKAGE_ARCH:visionsom-imx93 = "${MACHINE_ARCH}"
